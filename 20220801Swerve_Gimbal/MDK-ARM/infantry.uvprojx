# Keil uVision project infantry.uvprojx, settings and files
target infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: infantry +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/AHRS;../User/BMI088;../User/DSP/Include;../User/Referee;../User/UI;../User/Tasks/auto_aim;../User/Tasks/chassis;../User/Tasks/gimbal;../User/Tasks/PressTime;../User/Tasks/referee_usart_task;../User/Tasks/Sensor_task;../User/Tasks/shoot_task;../User/Tasks/SuperCapTask;../User/Tasks/usart_debug;../User/User_Driver/can_receive;../User/User_Driver/filter;../User/User_Driver/kalman_filter;../User/User_Driver/remote_control;../User/User_Driver/pid;../support;../User/Ist8310;../User/BSP
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group User_Drivers
    ../User/User_Driver/can_receive/: can_receive.c
    ../User/User_Driver/pid/: pid.c
    ../User/User_Driver/remote_control/: remote.c
    ../User/BSP/: bsp_adc.c bsp_spi.c bsp_delay.c bsp_flash.c
    ../User/User_Driver/filter/: filter.c
    ../User/User_Driver/kalman_filter/: kalman_filter.c
    ../User/UI/: INFANTRY_picture.c
    ../User/AHRS/: AHRS_middleware.c AHRS.lib
    ../User/BMI088/: ist8310driver.c ist8310driver_middleware.c BMI088driver.c BMI088Middleware.c
    ../User/DSP/: arm_cortexM4lf_math.lib
    ../Core/Src/: fifo_float.c
  group Tasks
    ../User/Tasks/auto_aim/: auto_aim_task.c
    ../User/Tasks/chassis/: chassis_task.c
    ../User/Tasks/gimbal/: gimbal_task.c
    ../User/Tasks/PressTime/: PressTime.c
    ../User/Tasks/referee_usart_task/: referee_usart_task.c
    ../User/Tasks/Sensor_task/: Sensor_task.c
    ../User/Tasks/shoot_task/: shoot_task.c
    ../User/Tasks/SuperCapTask/: SupercapTask.c
    ../User/Tasks/usart_debug/: usart_debug.c
  group Support
    ../support/: fifo.c mem_mang4.c mf_crc.c struct_typedef.h
  group Referee
    ../User/Referee/: referee.c CRC8_CRC16.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
